# IAR project HidHotkeys.ewp, settings and files
configuration CC2541DK-MINI Keyfob Slave (8051, debug)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_KEY=TRUE; HAL_LCD=FALSE; HAL_LED=TRUE; CC2540_MINIDK; DC_DC_P0_7; GAP_CHAR_CFG_MAX=6
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\..\..\Components\ble\ROM; ..\..\common\cc2540; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\Roles; ..\..\Profiles\HidDevKbd\CC254x; ..\..\Profiles\HidDevKbd; ..\..\Profiles\HidDev\CC254x; ..\..\Profiles\DevInfo; ..\..\Profiles\Batt\CC254x; ..\..\Profiles\ScanParam\CC254x; ..\..\Profiles\ScanParam
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=TRUE; HAL_LED=FALSE; HAL_KEY=TRUE
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\..\..\Components\ble\ROM; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile\CC254x; ..\..\Profiles\SimpleProfile; ..\..\Profiles\HidDevKbd\CC254x; ..\..\Profiles\HidDevKbd; ..\..\Profiles\HidDev\CC254x; ..\..\Profiles\DevInfo; ..\..\Profiles\Batt\CC254x; ..\..\Profiles\ScanParam\CC254x; ..\..\Profiles\ScanParam; ..\..\Profiles\Keys\CC254x; ..\..\Profiles\Keys
  group APP
    ../Source/: HidHotkeys.c HidHotkeys.h HidHotkeys_Main.c OSAL_HidHotkeys.c
  group HAL/Common
    $EW_DIR$/TI/BLE-CC254x-1.5.2.0/Components/hal/common/: hal_drivers.c
  group HAL/Include
    $EW_DIR$/TI/BLE-CC254x-1.5.2.0/Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    $EW_DIR$/TI/BLE-CC254x-1.5.2.0/Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    $EW_DIR$/TI/BLE-CC254x-1.5.2.0/Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    $EW_DIR$/TI/BLE-CC254x-1.5.2.0/Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    $EW_DIR$/TI/BLE-CC254x-1.5.2.0/Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    $EW_DIR$/TI/BLE-CC254x-1.5.2.0/Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    $EW_DIR$/TI/BLE-CC254x-1.5.2.0/Components/ble/host/: linkdb.h
    $EW_DIR$/TI/BLE-CC254x-1.5.2.0/Components/ble/controller/CC254x/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi_spi.c npi_uart.c
  group OSAL
    $EW_DIR$/TI/BLE-CC254x-1.5.2.0/Components/ble/include/: bcomdef.h
    $EW_DIR$/TI/BLE-CC254x-1.5.2.0/Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    $EW_DIR$/TI/BLE-CC254x-1.5.2.0/Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Batt/CC254x/: battservice.c battservice.h
    ../../Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h
    ../../Include/: gapgattserver.h gattservapp.h
    $EW_DIR$/TI/BLE-CC254x-1.5.2.0/Components/ble/host/: gatt_uuid.c
    ../../Profiles/GATT/: gattservapp_util.c
    ../../Profiles/HIDDev/CC254x/: hiddev.c hiddev.h
    ../../Profiles/HIDDevKbd/CC254x/: hidkbdservice.c
    ../../Profiles/HidDevKbd/: hidkbdservice.h
    ../../Profiles/Roles/CC254x/: peripheral.c peripheral.h
    ../../Profiles/ScanParam/CC254x/: scanparamservice.c
    ../../Profiles/ScanParam/: scanparamservice.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
