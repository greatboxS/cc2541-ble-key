<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HidHotkeys.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>HidHotkeys</project>
        <configuration>CC2541</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>